## boards/shields/mulkey/Kconfig.shield
```kconfig
config SHIELD_MULKEY_R
    def_bool $(shields_list_contains,mulkey_R)

config SHIELD_MULKEY_L
    def_bool $(shields_list_contains,mulkey_L)
```
